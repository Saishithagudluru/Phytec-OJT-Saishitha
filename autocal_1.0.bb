DESCRIPTION = "Simple auto calci application"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI = "file://auto-cal-1.0.tar.gz "
        

#S = "${WORKDIR}"
S = "${WORKDIR}/auto-cal-1.0"
inherit autotools








